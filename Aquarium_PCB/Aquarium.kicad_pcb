# Repository whsMCU/Aquarium

## KiCad design Aquarium_PCB/Aquarium.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H15, H16: MountingHole; MountingHole_3.2mm_M3
J1: GPIO; PinSocket_2x20_P2.54mm_Vertical
J2: Ultra Sonic Sensor; PinSocket_1x03_P2.54mm_Vertical
J3: TFT_LCD; PinSocket_1x08_P2.54mm_Vertical
J4: SDIO Card; PinSocket_1x08_P2.54mm_Vertical
J5: TDS Sensor; PinSocket_1x03_P2.54mm_Vertical
J6: Relay Board; PinSocket_1x06_P2.54mm_Vertical
J7: Buzzer; PinSocket_1x03_P2.54mm_Vertical
J8, J9: Conn_01x20_Female; PinSocket_1x20_P2.54mm_Vertical
J10: UART; PinSocket_1x04_P2.54mm_Vertical
J11: TEMP Sensor; PinSocket_1x03_P2.54mm_Vertical
J12: Relay1_OUT; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J13: Relay2_OUT; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J14: Relay3_OUT; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J15: Relay4_OUT; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J16: 220VAC; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J17: Relay1; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J18: Relay3; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J19: Relay2; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J20: Relay4; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J21: Button Board; PinSocket_1x06_P2.54mm_Vertical

Connections:
+3.3V: J1.1, J1.17, J3.4, J4.1, J8.20, J9.3, J11.1, J21.6
+5V: J1.2, J1.4, J2.1, J3.1, J5.2, J6.6, J7.1, J8.18, J9.1, J10.1
/A0_button_user: J9.15
/A1_TDS: J5.3, J9.14
/A2_LCD_BKL: J3.8, J9.13
/A3_LCD_CS: J3.3, J9.12
/A4_LCD_DC: J3.5, J9.11
/A5_LCD_SCK: J3.7, J9.10
/A6_SDIO_CMD: J4.5, J9.9
/A7_LCD_MOSI: J3.6, J9.8
/A8_SDIO_D1: J4.8, J8.5
/A9_SDIO_D2: J4.3, J8.6
/A10_UART1_RX: J8.7, J10.4
/A11_Relay3: J6.4, J8.8
/A12_Relay4: J6.5, J8.9
/A15: J8.10
/B0_TEMP: J9.7, J11.2
/B1_Sonar: J2.2, J9.6
/B2_button_left: J9.5, J21.2
/B3_Relay1: J6.2, J8.11
/B4_Relay2: J6.3, J8.12
/B5_SDIO_D3: J4.4, J8.13
/B6_UART1_TX: J8.14, J10.3
/B7_SDIO_D0: J4.7, J8.15
/B8: J8.16
/B9: J8.17
/B10_button_right: J9.4, J21.3
/B12_button_enter: J8.1, J21.4
/B13_button_exit: J8.2, J21.5
/B14_Buzzer: J7.2, J8.3
/B15_SDIO_CK: J4.6, J8.4
/C13: J9.19
/C14: J9.18
/C15: J9.17
/GPIO[2]/SDA1: J1.3
/GPIO[3]/SCL1: J1.5
/GPIO[4]/GPCLK0: J1.7
/GPIO[5]: J1.29
/GPIO[6]: J1.31
/GPIO[7]/SPI0.CE1: J1.26
/GPIO[8]/SPI0.CE0: J1.24
/GPIO[9]/SPI0.MISO: J1.21
/GPIO[10]/SPI0.MOSI: J1.19
/GPIO[11]/SPI0.SCLK: J1.23
/GPIO[12]/PWM0: J1.32
/GPIO[13]/PWM1: J1.33
/GPIO[14]/TXD0: J1.8
/GPIO[15]/RXD0: J1.10
/GPIO[16]: J1.36
/GPIO[17]: J1.11
/GPIO[18]/PCM.CLK: J1.12
/GPIO[19]/PCM.FS: J1.35
/GPIO[20]/PCM.DIN: J1.38
/GPIO[21]/PCM.DOUT: J1.40
/GPIO[22]: J1.15
/GPIO[23]: J1.16
/GPIO[24]: J1.18
/GPIO[25]: J1.22
/GPIO[26]: J1.37
/GPIO[27]: J1.13
/ID_SCL: J1.28
/ID_SDA: J1.27
/L: J12.1, J13.1, J14.1, J15.1, J16.1
/R: J9.16
/Relay1_A: J12.2, J17.2
/Relay2_A: J13.2, J19.2
/Relay3_A: J14.2, J18.2
/Relay4_A: J15.2, J20.2
/Relay_Com_N: J16.2, J17.1, J18.1, J19.1, J20.1
/VB: J9.20
GND: J1.6, J1.9, J1.14, J1.20, J1.25, J1.30, J1.34, J1.39, J2.3, J3.2, J4.2, J5.1, J6.1, J7.3, J8.19, J9.2, J10.2, J11.3, J21.1

Notes on the sheet:
초음파센서
Relay4
Relay1
Relay4_OUT
PCB Hole
Additional pin functions: https://pinout.xyz/
Relay Board Hole
Relay1_OUT
Button Board
Relay2_OUT
초으마센서
Button Board Hole
TDS Sensor
SDIO Card
Relay3
Relay3_OUT
UART
TEMP Sensor
Relay2
TFT_LCD
220VAC
Ultra Sonic Sensor
MCU
Buzzer
TIT LCD Board Hole
Relay Board

Board: 2 copper layers, 150.0 x 150.0 mm, 41 parts (0 on the bottom side), 34 nets.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_2.7mm_M2.5

## Commit log

2021-08-12 MCU Setting
2021-08-12 Add_led funtion
2021-08-14 Add Button, GPIO
2021-08-15 Modify_Button
2021-08-16 ADD_OneWire for DB18B20
2021-08-17 ADD_DS18B20, Modify_Onewire file. (DS18B20 Data received)
2021-08-19 CLCD 추가
2021-08-20 CLI 추가 및 온도센서 NON-blocking 구현
2021-08-21 초음파거리센서 추가
2021-08-22 초음파센서 변수 크기 조정
2021-08-23 초음파센서 버그 수정(CCR값 읽기만 가능해서 생긴 오지시)
2021-08-26 TFT LCD 추가 중
2021-08-26 TFT LCD 추가
2021-08-27 TFT LCD 버그 수정
2021-08-28 TDS 센서 추가 중
2021-08-29 ADC DMA로인해 프로그램 진행안되는 문제 해결하기
2021-08-29 TDS 센서 아날로그 DMA 성공 및 PPM 변환
2021-09-01 TFT LCD 버튼 구현 중
2021-09-04 BUZZER 추가
2021-09-05 sd카드 추가
2021-09-06 fatfs 파일시스템 추가
2021-09-07 DS18B20_CLI 메뉴 추가
2021-09-08 DS18B20 Non-block 및 TFT LCD RGB 색상 설정 변경
2021-09-10 사용자 버튼 추가
2021-09-12 TFT 이미지 출력기능 업데이트 중
2021-09-13 TFT LCD 이미지 출력 업데이트
2021-09-17 TFT LCD 상태 그래픽 추가 테스트
2022-03-11 업데이트
2022-03-16 새로운환경에서 push
2022-04-04 Add for 4 Relay Module
2022-04-14 Adding Menu system
2022-05-04 modify for HMI
2022-05-05 modify for etc..
2022-05-07 modify for button funtion.
2022-05-11 modify for menu system
2022-06-23 adding Telemetry
2022-07-04 adding Telemetry~!
2022-07-14 modify for telemetry~!
2022-08-05 for boot
2022-08-05 Adding Boot System
2022-08-05 modify program
2022-08-05 modify for boot
2022-08-10 modify for remote boot
2022-08-11 fix error for jump to app
2022-08-18 modify for menu
2022-08-19 modify for menu and mode
2022-08-22 modify for auto menu
2022-08-22 modify for setting menu
2022-09-02 modify for setting mode
2022-09-05 adding auto logic
2022-09-05 modify for auto logic
2022-09-26 modify for telemetry, db
2022-11-03 modify for button funtion
2022-11-11 modify for ap
2022-11-14 modify for bug
2022-11-16 Adding for PCB
2022-11-16 변수이름 변경 및 오토 로직 수정
2022-11-18 스위치 버튼 변경에 따른 수정
2022-11-19 버튼변경에 따른 수정
2022-11-20 버튼 풀다운으로 변경(F411 B2 풀업불량)
2022-11-24 자동환수 Sequence 추가
2022-11-24 자동환수 시퀀스 수정
2022-12-14 수족관 레벨 세팅치 변경
2022-12-19 자동환수 진행사항 표기 및 레벨센서 감도 조절
2022-12-20 PHP 제어를 위한 수정
